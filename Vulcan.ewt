<?xml version="1.0" encoding="iso-8859-1"?>

<project>
  <fileVersion>2</fileVersion>
  <configuration>
    <name>Vulcan</name>
    <toolchain>
      <name>ARM</name>
    </toolchain>
    <debug>1</debug>
    <settings>
      <name>RuntimeChecking</name>
      <archiveVersion>0</archiveVersion>
      <data>
        <version>2</version>
        <wantNonLocal>1</wantNonLocal>
        <debug>1</debug>
        <option>
          <name>GenRtcDebugHeap</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnableBoundsChecking</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrMem</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcTrackPointerBounds</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcCheckAccesses</name>
          <state>1</state>
        </option>
        <option>
          <name>GenRtcGenerateEntries</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcNrTrackedPointers</name>
          <state>1000</state>
        </option>
        <option>
          <name>GenRtcIntOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIncUnsigned</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntConversion</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclExplicit</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcIntShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcInclUnsignedShiftOverflow</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcUnhandledCase</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcDivByZero</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcEnable</name>
          <state>0</state>
        </option>
        <option>
          <name>GenRtcCheckPtrsNonInstrFunc</name>
          <state>1</state>
        </option>
      </data>
    </settings>
  </configuration>
  <group>
    <name>Boot</name>
    <group>
      <name>API</name>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Boot.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Boot_it.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Bootflash.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\HT1381.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Mx25L1606E.c</name>
      </file>
    </group>
    <group>
      <name>CMSIS</name>
      <file>
        <name>$PROJ_DIR$\BootAPI\src\Boot_startup_stm32f205xx.s</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\system_stm32f2xx.c</name>
      </file>
    </group>
    <group>
      <name>FAT</name>
      <group>
        <name>MST</name>
        <file>
          <name>$PROJ_DIR$\Libraries\FileSystem\fat\src\mst\mst.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Libraries\FileSystem\fat\src\common\common.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\FileSystem\fat\src\common\fat.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\FileSystem\fat\src\common\fat_lfn.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\FileSystem\fat\src\common\fat_m.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\FileSystem\fat\src\common\port_f.c</name>
      </file>
    </group>
    <group>
      <name>OS</name>
      <file>
        <name>$PROJ_DIR$\Libraries\FileSystem\os\nrtos\os_nrtos.c</name>
      </file>
    </group>
    <group>
      <name>USB_HOST</name>
      <group>
        <name>PMGR</name>
        <file>
          <name>$PROJ_DIR$\Libraries\FileSystem\usb_host\pmgr\pmgr.c</name>
        </file>
      </group>
      <group>
        <name>STM32uh</name>
        <file>
          <name>$PROJ_DIR$\Libraries\FileSystem\usb_host\stm32uh\stm32uh.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\FileSystem\usb_host\stm32uh\stm32uh_hub.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\FileSystem\usb_host\stm32uh\stm32uh_hw.c</name>
        </file>
      </group>
      <group>
        <name>USB_DRIVER</name>
        <group>
          <name>MST</name>
          <file>
            <name>$PROJ_DIR$\Libraries\FileSystem\usb_host\usb_driver\mst\scsi.c</name>
          </file>
          <file>
            <name>$PROJ_DIR$\Libraries\FileSystem\usb_host\usb_driver\mst\usb_mst.c</name>
          </file>
        </group>
        <file>
          <name>$PROJ_DIR$\Libraries\FileSystem\usb_host\usb_host.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\FileSystem\usb_host\usb_utils.c</name>
        </file>
      </group>
    </group>
  </group>
  <group>
    <name>UserProgram</name>
    <group>
      <name>API</name>
      <group>
        <name>WiFi</name>
        <file>
          <name>$PROJ_DIR$\SourceCode\WiFi_lib\CRC.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SourceCode\WiFi_lib\wifi_Digital.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SourceCode\WiFi_lib\wifi_event_handlers.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SourceCode\WiFi_lib\WiFi_Information.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\SourceCode\WiFi_lib\wifi_interface.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\SourceCode\Beep.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\C_safe_v5.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\Console.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\Digital.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\EEPRom.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\EEPROM_Langauge.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\EngineerMode.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\Formula.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\heart.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\HRM8700.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\i2c_key.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\keyboard.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\KeyFunction.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\LCB_Support.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\led.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\main.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\PingDefine.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\RF900.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\Show.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\Show_Functions.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\Timer.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\TV.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\UART.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\SourceCode\UsbFunction.c</name>
      </file>
    </group>
    <group>
      <name>LowLevelInitial</name>
      <file>
        <name>$PROJ_DIR$\BootAPI\LowLevelInitial\manual_init.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\BootAPI\LowLevelInitial\ucb_stm32f205xx.s</name>
      </file>
    </group>
    <group>
      <name>STM32_Lib</name>
      <group>
        <name>STM32F2xx_HAL_Driver</name>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_adc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_adc_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_cortex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_flash.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_flash_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_gpio.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_i2c.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_pwr.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_pwr_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_rcc.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_rcc_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_tim.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_tim_ex.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_hal_uart.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_exti.c</name>
        </file>
        <file>
          <name>$PROJ_DIR$\Libraries\STM32F2xx_HAL_Driver\Src\stm32f2xx_ll_gpio.c</name>
        </file>
      </group>
      <file>
        <name>$PROJ_DIR$\Libraries\stm32f2xx_hal_msp.c</name>
      </file>
      <file>
        <name>$PROJ_DIR$\Libraries\stm32f2xx_it.c</name>
      </file>
    </group>
  </group>
</project>


