# IAR project Vulcan.ewp, settings and files
configuration Vulcan (ARM, debug)
  General.OGChipSelectEditMenu: STM32F205VG ST STM32F205VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F205xx; USE_FULL_LL_DRIVER
  ICCARM.CCIncludePath2: Inc; BootAPI\inc\; Libraries; Libraries\STM32F2xx_HAL_Driver\Inc; Libraries\STM32F2xx_HAL_Driver\Inc\Legacy; Libraries\CMSIS\Device\ST\STM32F2xx\Include; Libraries\CMSIS\Include; Libraries\FileSystem\fat\src\common\; Libraries\FileSystem\fat\src\mst\; Libraries\FileSystem\os\; Libraries\FileSystem\os\nrtos\; Libraries\FileSystem\; Libraries\FileSystem\usb_host\; Libraries\FileSystem\usb_host\usb_driver\; Libraries\FileSystem\usb_host\usb_driver\mst\; Libraries\FileSystem\usb_host\pmgr\; Libraries\FileSystem\usb_host\stm32uh\; Sourcecode\WiFi_lib\; Sourcecode\inc\
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: Vulcan.bin
  ILINK.IlinkOutputFile: Vulcan.out
  ILINK.IlinkIcfFile: Config\JIS_stm32f205xx_flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Boot/API
    BootAPI/src/: Boot.c Boot_it.c Bootflash.c HT1381.c Mx25L1606E.c
  group Boot/CMSIS
    BootAPI/src/: Boot_startup_stm32f205xx.s
    Libraries/: system_stm32f2xx.c
  group Boot/FAT
    Libraries/FileSystem/fat/src/common/: common.c fat.c fat_lfn.c fat_m.c port_f.c
  group Boot/FAT/MST
    Libraries/FileSystem/fat/src/mst/: mst.c
  group Boot/OS
    Libraries/FileSystem/os/nrtos/: os_nrtos.c
  group Boot/USB_HOST/PMGR
    Libraries/FileSystem/usb_host/pmgr/: pmgr.c
  group Boot/USB_HOST/STM32uh
    Libraries/FileSystem/usb_host/stm32uh/: stm32uh.c stm32uh_hub.c stm32uh_hw.c
  group Boot/USB_HOST/USB_DRIVER
    Libraries/FileSystem/usb_host/: usb_host.c usb_utils.c
  group Boot/USB_HOST/USB_DRIVER/MST
    Libraries/FileSystem/usb_host/usb_driver/mst/: scsi.c usb_mst.c
  group UserProgram/API
    SourceCode/: Beep.c C_safe_v5.c Console.c Digital.c EEPRom.c EEPROM_Langauge.c EngineerMode.c Formula.c heart.c HRM8700.c i2c_key.c keyboard.c KeyFunction.c LCB_Support.c led.c main.c PingDefine.c RF900.c Show.c Show_Functions.c Timer.c TV.c UART.c UsbFunction.c
  group UserProgram/API/WiFi
    SourceCode/WiFi_lib/: CRC.c wifi_Digital.c wifi_event_handlers.c WiFi_Information.c wifi_interface.c
  group UserProgram/LowLevelInitial
    BootAPI/LowLevelInitial/: manual_init.c ucb_stm32f205xx.s
  group UserProgram/STM32_Lib
    Libraries/: stm32f2xx_hal_msp.c stm32f2xx_it.c
  group UserProgram/STM32_Lib/STM32F2xx_HAL_Driver
    Libraries/STM32F2xx_HAL_Driver/Src/: stm32f2xx_hal.c stm32f2xx_hal_adc.c stm32f2xx_hal_adc_ex.c stm32f2xx_hal_cortex.c stm32f2xx_hal_flash.c stm32f2xx_hal_flash_ex.c stm32f2xx_hal_gpio.c stm32f2xx_hal_i2c.c stm32f2xx_hal_pwr.c stm32f2xx_hal_pwr_ex.c stm32f2xx_hal_rcc.c stm32f2xx_hal_rcc_ex.c stm32f2xx_hal_tim.c stm32f2xx_hal_tim_ex.c stm32f2xx_hal_uart.c stm32f2xx_ll_exti.c stm32f2xx_ll_gpio.c
